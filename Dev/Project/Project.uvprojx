# Keil uVision project Project.uvprojx, settings and files
target Open207V (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c define: STM32F4XX, USE_STDPERIPH_DRIVER, TPP_RELEASE
  c include: ..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\_Common;..\MotorEncoder\BALANCE\CONTROL;..\MotorEncoder\HARDWARE\MOTOR;..\MotorEncoder\HARDWARE\ENCODER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
    ../../_Common/: config.c usart.c config.h
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Readme
    ../User/: readme.txt
  group MotorEncoder
    ../MotorEncoder/HARDWARE/MOTOR/: motor.c
    ../MotorEncoder/HARDWARE/ENCODER/: encoder.c
    ../MotorEncoder/BALANCE/CONTROL/: control.c
